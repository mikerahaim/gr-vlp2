<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>opt_power_2_distance</value></param>
<param><key>author</key><value>Richard McAllister</value></param>
<param><key>description</key><value>Requires gr-vlc installed</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Opt power To D Example</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>CtCr</value></param>
<param><key>value</key><value>1.1</value></param>
<param><key>gui_hint</key><value>8,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.005</value></param>
<param><key>stop</key><value>1.6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>angle</value></param>
<param><key>value</key><value>numpy.arccos(  dZ/distance )  * (180/math.pi)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>coords</value></param>
<param><key>value</key><value>( 2, 2,dZ)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dZ</value></param>
<param><key>value</key><value>1.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>distance</value></param>
<param><key>value</key><value>numpy.sqrt(  (x_var-coords[0])**2 + (y_var-coords[0])**2 + (dZ**2) )</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>goertzel_size</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lam_order</value></param>
<param><key>value</key><value>.88</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_ampl</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>8,0</value></param>
<param><key>label</key><value>Noise</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.0005</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(256e3)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_ampl</value></param>
<param><key>value</key><value>.7</value></param>
<param><key>gui_hint</key><value>2,0</value></param>
<param><key>label</key><value>Tx Power</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.005</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>distance</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>label</key><value>Actual Distance from Beacon</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>x_var</value></param>
<param><key>value</key><value>2</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>label</key><value>X</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.05</value></param>
<param><key>stop</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>y_var</value></param>
<param><key>value</key><value>2</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>label</key><value>Y</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.05</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>noise_ampl</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>tx_ampl</value></param>
<param><key>freq</key><value>tx_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>"Estimated Distance from Beacon"</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0</value></param>
<param><key>psi</key><value>angle</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>distance</value></param>
<param><key>phi</key><value>angle</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlp2_amp2d_ff</key>
<param><key>id</key><value>vlp2_amp2d_ff_0</value></param>
<param><key>fov</key><value>90</value></param>
<param><key>n</key><value>1</value></param>
<param><key>Ts</key><value>1</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>tx_number</key><value>1</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>Ax</key><value>tx_ampl</value></param>
<param><key>CtCr</key><value>CtCr</value></param>
<param><key>Dz</key><value>dZ</value></param>
</block>
<block>
<key>vlp_goertzel</key>
<param><key>id</key><value>vlp_goertzel_0</value></param>
<param><key>mult</key><value>2</value></param>
<param><key>freq</key><value>tx_freq</value></param>
<param><key>goertzel_size</key><value>goertzel_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>vlc_channel_relative_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0</source_block_id><sink_block_id>vlp_goertzel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp_goertzel_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
