<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>multilateration</value></param>
<param><key>author</key><value>Richard McAllister</value></param>
<param><key>description</key><value>This block demonstrates how the multilateration block works</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Multilateration Example</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX_coords</value></param>
<param><key>value</key><value>( (3.75,1.75,dZ ), (3.75, 1,dZ), (3.75, .25, dZ), (3, 1.75, dZ), (3, .75, dZ), (3, .25, dZ), (2.25, 1.75, dZ), (2.25, .75, dZ), (2.25, .25, dZ), (1.5,1.75,dZ), (1.5,.75,dZ), (1.5,.25,dZ), (.75,1.75,dZ), (.75,.75,dZ), (.75,.25,dZ) )
</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>angles</value></param>
<param><key>value</key><value>( numpy.arccos(  dZ/distances[0]  )  * (180/math.pi),numpy.arccos(  dZ/distances[1]  )  * (180/math.pi),numpy.arccos(  dZ/distances[2]   ) * (180/math.pi),numpy.arccos(  dZ/distances[3]   ) * (180/math.pi),numpy.arccos(  dZ/distances[4] ) * (180/math.pi), numpy.arccos(  dZ/distances[4]   ) * (180/math.pi),numpy.arccos(  dZ/distances[5] ) * (180/math.pi), numpy.arccos(  dZ/distances[6]   ) * (180/math.pi),numpy.arccos(  dZ/distances[7]  ) * (180/math.pi), numpy.arccos(  dZ/distances[8] ) * (180/math.pi), numpy.arccos(  dZ/distances[9] ) * (180/math.pi), numpy.arccos(  dZ/distances[10]   ) * (180/math.pi),numpy.arccos(  dZ/distances[11] ) * (180/math.pi), numpy.arccos(  dZ/distances[12]   ) * (180/math.pi),numpy.arccos(  dZ/distances[13]  ) * (180/math.pi),numpy.arccos(  dZ/distances[14]  ) * (180/math.pi))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dZ</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>distances</value></param>
<param><key>value</key><value>( numpy.sqrt(  (x_var-TX_coords[0][0])**2 + (y_var-TX_coords[0][1])**2 + (dZ**2) ), numpy.sqrt(  (x_var-TX_coords[1][0])**2 + (y_var-TX_coords[1][1])**2 + (dZ**2) ), numpy.sqrt(  (x_var-TX_coords[2][0])**2 + (y_var-TX_coords[2][1])**2 + (dZ**2) ), numpy.sqrt(  (x_var-TX_coords[3][0])**2 + (y_var-TX_coords[3][1])**2 + (dZ**2) ), numpy.sqrt(  (x_var-TX_coords[4][0])**2 + (y_var-TX_coords[4][1])**2 + (dZ**2) ), numpy.sqrt(  (x_var-TX_coords[5][0])**2 + (y_var-TX_coords[5][1])**2 + (dZ**2) ), numpy.sqrt(  (x_var-TX_coords[6][0])**2 + (y_var-TX_coords[6][1])**2 + (dZ**2) ),  numpy.sqrt(  (x_var-TX_coords[7][0])**2 + (y_var-TX_coords[7][1])**2 + (dZ**2) ), numpy.sqrt(  (x_var-TX_coords[8][0])**2 + (y_var-TX_coords[8][1])**2 + (dZ**2) ), numpy.sqrt(  (x_var-TX_coords[9][0])**2 + (y_var-TX_coords[9][1])**2 + (dZ**2) ), numpy.sqrt(  (x_var-TX_coords[10][0])**2 + (y_var-TX_coords[10][1])**2 + (dZ**2) ), numpy.sqrt(  (x_var-TX_coords[11][0])**2 + (y_var-TX_coords[11][1])**2 + (dZ**2) ), numpy.sqrt(  (x_var-TX_coords[12][0])**2 + (y_var-TX_coords[12][1])**2 + (dZ**2) ), numpy.sqrt(  (x_var-TX_coords[13][0])**2 + (y_var-TX_coords[13][1])**2 + (dZ**2) ), numpy.sqrt(  (x_var-TX_coords[14][0])**2 + (y_var-TX_coords[14][1])**2 + (dZ**2) ) )</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(512e3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_number</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>x_var</value></param>
<param><key>value</key><value>2</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>label</key><value>X</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.05</value></param>
<param><key>stop</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>y_var</value></param>
<param><key>value</key><value>2</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>label</key><value>Y</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.05</value></param>
<param><key>stop</key><value>4</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>distances[0]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>distances[1]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0_0</value></param>
<param><key>const</key><value>distances[4]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0_1</value></param>
<param><key>const</key><value>distances[7]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0_2</value></param>
<param><key>const</key><value>distances[10]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0_3</value></param>
<param><key>const</key><value>distances[13]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_1</value></param>
<param><key>const</key><value>distances[2]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_1_0</value></param>
<param><key>const</key><value>distances[5]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_1_1</value></param>
<param><key>const</key><value>distances[8]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_1_2</value></param>
<param><key>const</key><value>distances[11]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_1_3</value></param>
<param><key>const</key><value>distances[14]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_2</value></param>
<param><key>const</key><value>distances[3]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_3</value></param>
<param><key>const</key><value>distances[6]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_4</value></param>
<param><key>const</key><value>distances[9]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_5</value></param>
<param><key>const</key><value>distances[12]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>XY Coordinates</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>xmax</key><value>4</value></param>
<param><key>xmin</key><value>0</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>X</value></param>
<param><key>label2</key><value>Y</value></param>
<param><key>max</key><value>4</value></param>
<param><key>min</key><value>0</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>update_time</key><value>0.01</value></param>
</block>
<block>
<key>vlp2_trilat_scaleable_ff</key>
<param><key>id</key><value>vlp2_trilat_scaleable_ff_0</value></param>
<param><key>tx_number</key><value>tx_number</value></param>
<param><key>tx_coords</key><value>TX_coords</value></param>
<param><key>tx_z</key><value>dZ</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0_1</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0_2</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>0</source_key><sink_key>10</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0_3</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>0</source_key><sink_key>13</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_1</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_1_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_1_1</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_1_2</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>0</source_key><sink_key>11</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_1_3</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>0</source_key><sink_key>14</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_2</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_3</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_4</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>0</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_5</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>0</source_key><sink_key>12</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
</flow_graph>
