<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>vlp_3x3_sim</value></param>
<param><key>author</key><value>Richard McAllister</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>VLP 3x3 Simulation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CtCr</value></param>
<param><key>value</key><value>1.3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX_coords</value></param>
<param><key>value</key><value>( (3.337,1.02,dZ ), (3.337, .81,dZ), (3.337, .3, dZ), (2.667, 1.32, dZ), (2.667, .81, dZ), (2.667, .3, dZ), (2.017, 1.32, dZ), (2.017, .81, dZ), (2.017, .3, dZ) )</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX_freqs</value></param>
<param><key>value</key><value>(1e5, 2e5, 3e5,4e5,5e5,6e5,7e5,8e5,9e5)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TXn_ampl</value></param>
<param><key>value</key><value>.7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>angles</value></param>
<param><key>value</key><value>( numpy.arccos(  dZ/distances[0]  )  * (180/math.pi), numpy.arccos(  dZ/distances[1]  )  * (180/math.pi), numpy.arccos(  dZ/distances[2]   ) * (180/math.pi), numpy.arccos(  dZ/distances[3]   ) * (180/math.pi), numpy.arccos(  dZ/distances[4] ) * (180/math.pi), numpy.arccos(  dZ/distances[4]   ) * (180/math.pi), numpy.arccos(  dZ/distances[5] ) * (180/math.pi), numpy.arccos(  dZ/distances[6]   ) * (180/math.pi), numpy.arccos(  dZ/distances[7]  ) * (180/math.pi), numpy.arccos(  dZ/distances[8] ) * (180/math.pi))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dZ</value></param>
<param><key>value</key><value>1.355</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>distances</value></param>
<param><key>value</key><value>( numpy.sqrt(  (x_var-TX_coords[0][0])**2 + (y_var-TX_coords[0][1])**2 + (dZ**2) ), numpy.sqrt(  (x_var-TX_coords[1][0])**2 + (y_var-TX_coords[1][1])**2 + (dZ**2) ), numpy.sqrt(  (x_var-TX_coords[2][0])**2 + (y_var-TX_coords[2][1])**2 + (dZ**2) ),          numpy.sqrt(  (x_var-TX_coords[3][0])**2 + (y_var-TX_coords[3][1])**2 + (dZ**2) ), numpy.sqrt(  (x_var-TX_coords[4][0])**2 + (y_var-TX_coords[4][1])**2 + (dZ**2) ), numpy.sqrt(  (x_var-TX_coords[5][0])**2 + (y_var-TX_coords[5][1])**2 + (dZ**2) ),
               numpy.sqrt(  (x_var-TX_coords[6][0])**2 + (y_var-TX_coords[6][1])**2 + (dZ**2) ), numpy.sqrt(  (x_var-TX_coords[7][0])**2 + (y_var-TX_coords[7][1])**2 + (dZ**2) ),numpy.sqrt(  (x_var-TX_coords[8][0])**2 + (y_var-TX_coords[8][1])**2 + (dZ**2) ) )</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>goertzel_size</value></param>
<param><key>value</key><value>int(2e3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lam_order</value></param>
<param><key>value</key><value>0.88</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_ampl</value></param>
<param><key>value</key><value>.005</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.0005</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(2e6)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_number</value></param>
<param><key>value</key><value>9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>x_var</value></param>
<param><key>value</key><value>3</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.05</value></param>
<param><key>stop</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>y_var</value></param>
<param><key>value</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.05</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>x_var</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_1</value></param>
<param><key>const</key><value>y_var</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>noise_ampl</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>TXn_ampl</value></param>
<param><key>freq</key><value>TX_freqs[0]</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>TXn_ampl</value></param>
<param><key>freq</key><value>TX_freqs[1]</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1</value></param>
<param><key>amp</key><value>TXn_ampl</value></param>
<param><key>freq</key><value>TX_freqs[2]</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_2</value></param>
<param><key>amp</key><value>TXn_ampl</value></param>
<param><key>freq</key><value>TX_freqs[3]</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_3</value></param>
<param><key>amp</key><value>TXn_ampl</value></param>
<param><key>freq</key><value>TX_freqs[4]</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_4</value></param>
<param><key>amp</key><value>TXn_ampl</value></param>
<param><key>freq</key><value>TX_freqs[5]</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_5</value></param>
<param><key>amp</key><value>TXn_ampl</value></param>
<param><key>freq</key><value>TX_freqs[6]</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_6</value></param>
<param><key>amp</key><value>TXn_ampl</value></param>
<param><key>freq</key><value>TX_freqs[7]</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_7</value></param>
<param><key>amp</key><value>TXn_ampl</value></param>
<param><key>freq</key><value>TX_freqs[8]</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>10</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_2</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_3</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_4</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_5</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_6</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_7</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_1</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_2</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_3</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_4</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_5</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_6</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_7</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0</value></param>
<param><key>freq</key><value>TX_freqs[0]</value></param>
<param><key>len</key><value>goertzel_size</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0_0</value></param>
<param><key>freq</key><value>TX_freqs[1]</value></param>
<param><key>len</key><value>goertzel_size</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0_1</value></param>
<param><key>freq</key><value>TX_freqs[2]</value></param>
<param><key>len</key><value>goertzel_size</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0_2</value></param>
<param><key>freq</key><value>TX_freqs[3]</value></param>
<param><key>len</key><value>goertzel_size</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0_3</value></param>
<param><key>freq</key><value>TX_freqs[4]</value></param>
<param><key>len</key><value>goertzel_size</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0_4</value></param>
<param><key>freq</key><value>TX_freqs[5]</value></param>
<param><key>len</key><value>goertzel_size</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0_5</value></param>
<param><key>freq</key><value>TX_freqs[6]</value></param>
<param><key>len</key><value>goertzel_size</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0_6</value></param>
<param><key>freq</key><value>TX_freqs[7]</value></param>
<param><key>len</key><value>goertzel_size</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0_7</value></param>
<param><key>freq</key><value>TX_freqs[8]</value></param>
<param><key>len</key><value>goertzel_size</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>my_tabs</value></param>
<param><key>label0</key><value>VLP</value></param>
<param><key>label1</key><value>Channel Model</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>my_tabs@0</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>4</value></param>
<param><key>xmin</key><value>0</value></param>
<param><key>ymax</key><value>3</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>my_tabs@1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>gui_hint</key><value>my_tabs@0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>4</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>my_tabs@1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0</value></param>
<param><key>psi</key><value>angles[0]</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>distances[0]</value></param>
<param><key>phi</key><value>angles[0]</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_0</value></param>
<param><key>psi</key><value>angles[1]</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>distances[1]</value></param>
<param><key>phi</key><value>angles[1]</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_1</value></param>
<param><key>psi</key><value>angles[2]</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>distances[2]</value></param>
<param><key>phi</key><value>angles[2]</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_2</value></param>
<param><key>psi</key><value>angles[3]</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>distances[3]</value></param>
<param><key>phi</key><value>angles[3]</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_3</value></param>
<param><key>psi</key><value>angles[5]</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>distances[5]</value></param>
<param><key>phi</key><value>angles[5]</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_4</value></param>
<param><key>psi</key><value>angles[6]</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>distances[6]</value></param>
<param><key>phi</key><value>angles[6]</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_5</value></param>
<param><key>psi</key><value>angles[7]</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>distances[7]</value></param>
<param><key>phi</key><value>angles[7]</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_6</value></param>
<param><key>psi</key><value>angles[8]</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>distances[8]</value></param>
<param><key>phi</key><value>angles[8]</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_7</value></param>
<param><key>psi</key><value>angles[4]</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>distances[4]</value></param>
<param><key>phi</key><value>angles[4]</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlp2_amp2d_ff</key>
<param><key>id</key><value>vlp2_amp2d_ff_0</value></param>
<param><key>fov</key><value>90</value></param>
<param><key>n</key><value>1</value></param>
<param><key>Ts</key><value>1</value></param>
<param><key>m</key><value>1</value></param>
<param><key>tx_number</key><value>tx_number</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>Ax</key><value>TXn_ampl</value></param>
<param><key>CtCr</key><value>(CtCr, CtCr, CtCr, CtCr, CtCr, CtCr, CtCr, CtCr, CtCr)</value></param>
<param><key>Dz</key><value>dZ</value></param>
</block>
<block>
<key>vlp2_trilat_scaleable_ff</key>
<param><key>id</key><value>vlp2_trilat_scaleable_ff_0</value></param>
<param><key>tx_number</key><value>tx_number</value></param>
<param><key>tx_coords</key><value>TX_coords</value></param>
<param><key>tx_z</key><value>dZ</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_1</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>vlc_channel_relative_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1</source_block_id><sink_block_id>vlc_channel_relative_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_2</source_block_id><sink_block_id>vlc_channel_relative_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_3</source_block_id><sink_block_id>vlc_channel_relative_0_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_4</source_block_id><sink_block_id>vlc_channel_relative_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_5</source_block_id><sink_block_id>vlc_channel_relative_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_6</source_block_id><sink_block_id>vlc_channel_relative_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_7</source_block_id><sink_block_id>vlc_channel_relative_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>goertzel_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>goertzel_fc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>goertzel_fc_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>goertzel_fc_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>goertzel_fc_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>goertzel_fc_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>goertzel_fc_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>goertzel_fc_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>goertzel_fc_0_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_3</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_4</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_5</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_6</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_7</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_1</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_2</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_3</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_4</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_5</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_6</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_7</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>vlc_channel_relative_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0_1</source_block_id><sink_block_id>blocks_complex_to_mag_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0_2</source_block_id><sink_block_id>blocks_complex_to_mag_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0_3</source_block_id><sink_block_id>blocks_complex_to_mag_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0_4</source_block_id><sink_block_id>blocks_complex_to_mag_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0_5</source_block_id><sink_block_id>blocks_complex_to_mag_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0_6</source_block_id><sink_block_id>blocks_complex_to_mag_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0_7</source_block_id><sink_block_id>blocks_complex_to_mag_0_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_3</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_4</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_5</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_6</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_7</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>6</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>7</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>8</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
</flow_graph>
