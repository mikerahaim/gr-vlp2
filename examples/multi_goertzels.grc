<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>multi_goertzel</value></param>
<param><key>author</key><value>Richard McAllister</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Multi Goertzel</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freqs</value></param>
<param><key>label</key><value>Frequencies</value></param>
<param><key>value</key><value>(1,1,1,1,1,1,1,1,1,1,1,1,1,1,1)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>goertzel_size</value></param>
<param><key>label</key><value>Goertzel Length</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mult</value></param>
<param><key>label</key><value>Const Mult</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_a</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_b</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_c</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out2</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_d</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out3</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_e</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out4</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_f</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out5</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_fa</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out6</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_g</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out7</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_h</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out8</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_i</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out9</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_j</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out10</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_k</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out11</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_l</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out12</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_m</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out13</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_n</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out14</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Rate</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>vlp_goertzel</key>
<param><key>id</key><value>vlp_goertzel_0</value></param>
<param><key>mult</key><value>2</value></param>
<param><key>freq</key><value>freqs[1]</value></param>
<param><key>goertzel_size</key><value>goertzel_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>vlp_goertzel</key>
<param><key>id</key><value>vlp_goertzel_0_0</value></param>
<param><key>mult</key><value>2</value></param>
<param><key>freq</key><value>freqs[2]</value></param>
<param><key>goertzel_size</key><value>goertzel_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>vlp_goertzel</key>
<param><key>id</key><value>vlp_goertzel_0_0_0</value></param>
<param><key>mult</key><value>2</value></param>
<param><key>freq</key><value>freqs[5]</value></param>
<param><key>goertzel_size</key><value>goertzel_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>vlp_goertzel</key>
<param><key>id</key><value>vlp_goertzel_0_0_0_0</value></param>
<param><key>mult</key><value>2</value></param>
<param><key>freq</key><value>freqs[11]</value></param>
<param><key>goertzel_size</key><value>goertzel_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>vlp_goertzel</key>
<param><key>id</key><value>vlp_goertzel_0_0_0_0_0</value></param>
<param><key>mult</key><value>2</value></param>
<param><key>freq</key><value>freqs[0]</value></param>
<param><key>goertzel_size</key><value>goertzel_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>vlp_goertzel</key>
<param><key>id</key><value>vlp_goertzel_0_0_1</value></param>
<param><key>mult</key><value>2</value></param>
<param><key>freq</key><value>freqs[8]</value></param>
<param><key>goertzel_size</key><value>goertzel_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>vlp_goertzel</key>
<param><key>id</key><value>vlp_goertzel_0_1</value></param>
<param><key>mult</key><value>2</value></param>
<param><key>freq</key><value>freqs[3]</value></param>
<param><key>goertzel_size</key><value>goertzel_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>vlp_goertzel</key>
<param><key>id</key><value>vlp_goertzel_0_1_0</value></param>
<param><key>mult</key><value>2</value></param>
<param><key>freq</key><value>freqs[6]</value></param>
<param><key>goertzel_size</key><value>goertzel_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>vlp_goertzel</key>
<param><key>id</key><value>vlp_goertzel_0_1_0_0</value></param>
<param><key>mult</key><value>2</value></param>
<param><key>freq</key><value>freqs[12]</value></param>
<param><key>goertzel_size</key><value>goertzel_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>vlp_goertzel</key>
<param><key>id</key><value>vlp_goertzel_0_1_0_0_0</value></param>
<param><key>mult</key><value>2</value></param>
<param><key>freq</key><value>freqs[14]</value></param>
<param><key>goertzel_size</key><value>goertzel_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>vlp_goertzel</key>
<param><key>id</key><value>vlp_goertzel_0_1_1</value></param>
<param><key>mult</key><value>2</value></param>
<param><key>freq</key><value>freqs[9]</value></param>
<param><key>goertzel_size</key><value>goertzel_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>vlp_goertzel</key>
<param><key>id</key><value>vlp_goertzel_0_2</value></param>
<param><key>mult</key><value>2</value></param>
<param><key>freq</key><value>freqs[4]</value></param>
<param><key>goertzel_size</key><value>goertzel_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>vlp_goertzel</key>
<param><key>id</key><value>vlp_goertzel_0_2_0</value></param>
<param><key>mult</key><value>2</value></param>
<param><key>freq</key><value>freqs[10]</value></param>
<param><key>goertzel_size</key><value>goertzel_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>vlp_goertzel</key>
<param><key>id</key><value>vlp_goertzel_0_2_0_0</value></param>
<param><key>mult</key><value>2</value></param>
<param><key>freq</key><value>freqs[13]</value></param>
<param><key>goertzel_size</key><value>goertzel_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>vlp_goertzel</key>
<param><key>id</key><value>vlp_goertzel_0_3</value></param>
<param><key>mult</key><value>2</value></param>
<param><key>freq</key><value>freqs[7]</value></param>
<param><key>goertzel_size</key><value>goertzel_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>vlp_goertzel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>vlp_goertzel_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>vlp_goertzel_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>vlp_goertzel_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>vlp_goertzel_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>vlp_goertzel_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>vlp_goertzel_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>vlp_goertzel_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>vlp_goertzel_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>vlp_goertzel_0_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>vlp_goertzel_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>vlp_goertzel_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>vlp_goertzel_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>vlp_goertzel_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>vlp_goertzel_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp_goertzel_0</source_block_id><sink_block_id>pad_sink_b</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp_goertzel_0_0</source_block_id><sink_block_id>pad_sink_c</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp_goertzel_0_0_0</source_block_id><sink_block_id>pad_sink_f</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp_goertzel_0_0_0_0</source_block_id><sink_block_id>pad_sink_k</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp_goertzel_0_0_0_0_0</source_block_id><sink_block_id>pad_sink_a</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp_goertzel_0_0_1</source_block_id><sink_block_id>pad_sink_h</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp_goertzel_0_1</source_block_id><sink_block_id>pad_sink_d</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp_goertzel_0_1_0</source_block_id><sink_block_id>pad_sink_fa</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp_goertzel_0_1_0_0</source_block_id><sink_block_id>pad_sink_l</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp_goertzel_0_1_0_0_0</source_block_id><sink_block_id>pad_sink_n</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp_goertzel_0_1_1</source_block_id><sink_block_id>pad_sink_i</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp_goertzel_0_2</source_block_id><sink_block_id>pad_sink_e</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp_goertzel_0_2_0</source_block_id><sink_block_id>pad_sink_j</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp_goertzel_0_2_0_0</source_block_id><sink_block_id>pad_sink_m</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp_goertzel_0_3</source_block_id><sink_block_id>pad_sink_g</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
