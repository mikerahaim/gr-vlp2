<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>channel_model_9x9_sim</value></param>
<param><key>author</key><value>Richard McAllister</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>9x9 Channel Model</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CtCr</value></param>
<param><key>value</key><value>1.3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>angle1</value></param>
<param><key>value</key><value>(numpy.arccos(  dZ/d1  ) ) * (180/math.pi)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>angle2</value></param>
<param><key>value</key><value>(numpy.arccos(  dZ/d2 ) ) * (180/math.pi)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>angle3</value></param>
<param><key>value</key><value>(numpy.arccos(  dZ/d3  ) ) * (180/math.pi)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>angle4</value></param>
<param><key>value</key><value>(numpy.arccos(  dZ/d4  ) ) * (180/math.pi)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>angle5</value></param>
<param><key>value</key><value>(numpy.arccos(  dZ/d5 ) ) * (180/math.pi)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>angle6</value></param>
<param><key>value</key><value>(numpy.arccos(  dZ/d6  ) ) * (180/math.pi)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>angle7</value></param>
<param><key>value</key><value>(numpy.arccos(  dZ/d7  ) ) * (180/math.pi)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>angle8</value></param>
<param><key>value</key><value>(numpy.arccos(  dZ/d8  ) ) * (180/math.pi)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>angle9</value></param>
<param><key>value</key><value>(numpy.arccos(  dZ/d9  ) ) * (180/math.pi)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d1</value></param>
<param><key>value</key><value>numpy.sqrt( (x_var-3.337)**2 + (y_var-1.02)**2 + dZ**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d2</value></param>
<param><key>value</key><value>numpy.sqrt( (x_var-3.337)**2 + (y_var-.81)**2 + dZ**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d3</value></param>
<param><key>value</key><value>numpy.sqrt( (x_var-3.337)**2 + (y_var-.3)**2 + dZ**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d4</value></param>
<param><key>value</key><value>numpy.sqrt( (x_var-2.677)**2 + (y_var-1.32)**2 + dZ**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d5</value></param>
<param><key>value</key><value>numpy.sqrt( (x_var-2.677)**2 + (y_var-.81)**2 + dZ**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d6</value></param>
<param><key>value</key><value>numpy.sqrt( (x_var-2.677)**2 + (y_var-.3)**2 + dZ**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d7</value></param>
<param><key>value</key><value>numpy.sqrt( (x_var-2.017)**2 + (y_var-1.32)**2 + dZ**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d8</value></param>
<param><key>value</key><value>numpy.sqrt( (x_var-2.017)**2 + (y_var-.81)**2 + dZ**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d9</value></param>
<param><key>value</key><value>numpy.sqrt( (x_var-2.017)**2 + (y_var-.3)**2 + dZ**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dZ</value></param>
<param><key>value</key><value>1.355</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lam_order</value></param>
<param><key>value</key><value>0.88</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>x_var</value></param>
<param><key>value</key><value>0.75</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.005</value></param>
<param><key>stop</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>y_var</value></param>
<param><key>value</key><value>.23</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.005</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>.001</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>4e5</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>5e5</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_2</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>200e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_3</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>100e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_4</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>8e5</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_5</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>7e5</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_6</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>6e5</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_7</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>3e5</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_8</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>9e5</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>10</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>rate</key><value>.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>0</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0</value></param>
<param><key>psi</key><value>angle1</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>d1</value></param>
<param><key>phi</key><value>angle1</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_0</value></param>
<param><key>psi</key><value>angle3</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>d3</value></param>
<param><key>phi</key><value>angle3</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_1</value></param>
<param><key>psi</key><value>angle2</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>d2</value></param>
<param><key>phi</key><value>angle2</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_2</value></param>
<param><key>psi</key><value>angle4</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>d4</value></param>
<param><key>phi</key><value>angle4</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_3</value></param>
<param><key>psi</key><value>angle5</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>d5</value></param>
<param><key>phi</key><value>angle5</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_4</value></param>
<param><key>psi</key><value>angle7</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>d7</value></param>
<param><key>phi</key><value>angle7</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_5</value></param>
<param><key>psi</key><value>angle6</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>d6</value></param>
<param><key>phi</key><value>angle6</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_6</value></param>
<param><key>psi</key><value>angle9</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>d9</value></param>
<param><key>phi</key><value>angle9</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_7</value></param>
<param><key>psi</key><value>angle8</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>d8</value></param>
<param><key>phi</key><value>angle8</value></param>
<param><key>Ts</key><value>CtCr</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>vlc_channel_relative_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>vlc_channel_relative_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_2</source_block_id><sink_block_id>vlc_channel_relative_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_3</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_4</source_block_id><sink_block_id>vlc_channel_relative_0_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_5</source_block_id><sink_block_id>vlc_channel_relative_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_6</source_block_id><sink_block_id>vlc_channel_relative_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_7</source_block_id><sink_block_id>vlc_channel_relative_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_8</source_block_id><sink_block_id>vlc_channel_relative_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>vlc_channel_relative_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_3</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_4</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_5</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_6</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_7</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
</flow_graph>
