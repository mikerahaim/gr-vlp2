<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>vlp_simulation_2x2</value></param>
<param><key>author</key><value>Richard McAllister, Mike Rahaim</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>VLP Simulation of 2x2 Array</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CtCr</value></param>
<param><key>value</key><value>[1.37567074, 1.45229190, 1.50731873, 1.39086524]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Dz</value></param>
<param><key>value</key><value>1.355</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX1_f</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX1_location</value></param>
<param><key>value</key><value>.75, .23, 0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX2_f</value></param>
<param><key>value</key><value>300000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX2_location</value></param>
<param><key>value</key><value>.25, 0.23, 0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX3_f</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX3_location</value></param>
<param><key>value</key><value>0.25, 0.93, 0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX4_f</value></param>
<param><key>value</key><value>400000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX4_location</value></param>
<param><key>value</key><value>0.750, 0.93, 0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TXn_ampl</value></param>
<param><key>value</key><value>0.7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>angle1</value></param>
<param><key>value</key><value>(numpy.arccos(  Dz/distance1  ) ) * (180/math.pi)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>angle2</value></param>
<param><key>value</key><value>(numpy.arccos(  Dz/distance2  ) ) * (180/math.pi)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>angle3</value></param>
<param><key>value</key><value>(numpy.arccos(  Dz/distance3 ) ) * (180/math.pi)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>angle4</value></param>
<param><key>value</key><value>(numpy.arccos(  Dz/distance4  ) ) * (180/math.pi)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>distance1</value></param>
<param><key>value</key><value>numpy.sqrt( (x_var-TX1_location[0])**2 + (y_var-TX1_location[1])**2 + Dz**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>distance2</value></param>
<param><key>value</key><value>numpy.sqrt( (x_var-TX2_location[0])**2 + (y_var-TX2_location[1])**2 + Dz**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>distance3</value></param>
<param><key>value</key><value>numpy.sqrt( (x_var-TX3_location[0])**2 + (y_var-TX3_location[1])**2 + Dz**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>distance4</value></param>
<param><key>value</key><value>numpy.sqrt( (x_var-TX4_location[0])**2 + (y_var-TX4_location[1])**2 + Dz**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>goertzel_size</value></param>
<param><key>value</key><value>2000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lam_order</value></param>
<param><key>value</key><value>0.88</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(2e6)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_number</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>x_var</value></param>
<param><key>value</key><value>0.75</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.005</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>y_var</value></param>
<param><key>value</key><value>.23</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.005</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>Position</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>X position</value></param>
<param><key>label2</key><value>Y position</value></param>
<param><key>name</key><value>"Receiver (2D) Position"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>.01</value></param>
<param><key>xmax</key><value>1.5</value></param>
<param><key>xmin</key><value>0</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>x_var</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_1</value></param>
<param><key>const</key><value>y_var</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>TXn_ampl</value></param>
<param><key>freq</key><value>TX1_f</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>amp</key><value>TXn_ampl</value></param>
<param><key>freq</key><value>TX2_f</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_2</value></param>
<param><key>amp</key><value>TXn_ampl</value></param>
<param><key>freq</key><value>TX4_f</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_3</value></param>
<param><key>amp</key><value>TXn_ampl</value></param>
<param><key>freq</key><value>TX3_f</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_2</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_2</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_2</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0</value></param>
<param><key>freq</key><value>TX1_f</value></param>
<param><key>len</key><value>goertzel_size</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0_0</value></param>
<param><key>freq</key><value>TX4_f</value></param>
<param><key>len</key><value>goertzel_size</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0_1</value></param>
<param><key>freq</key><value>TX3_f</value></param>
<param><key>len</key><value>goertzel_size</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0_2</value></param>
<param><key>freq</key><value>TX2_f</value></param>
<param><key>len</key><value>goertzel_size</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>nconnections</key><value>4</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>X Estimate</value></param>
<param><key>label2</key><value>Y Estimate</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0</value></param>
<param><key>psi</key><value>angle1</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>distance1</value></param>
<param><key>phi</key><value>angle1</value></param>
<param><key>Ts</key><value>CtCr[0]</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_0</value></param>
<param><key>psi</key><value>angle2</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>distance2</value></param>
<param><key>phi</key><value>angle2</value></param>
<param><key>Ts</key><value>CtCr[1]</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_1</value></param>
<param><key>psi</key><value>angle3</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>distance3</value></param>
<param><key>phi</key><value>angle3</value></param>
<param><key>Ts</key><value>CtCr[2]</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0_2</value></param>
<param><key>psi</key><value>angle4</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>distance4</value></param>
<param><key>phi</key><value>angle4</value></param>
<param><key>Ts</key><value>CtCr[3]</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<block>
<key>vlp2_amp2d_ff</key>
<param><key>id</key><value>vlp2_amp2d_ff_0</value></param>
<param><key>fov</key><value>90</value></param>
<param><key>n</key><value>1</value></param>
<param><key>Ts</key><value>1</value></param>
<param><key>m</key><value>lam_order</value></param>
<param><key>tx_number</key><value>tx_number</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>Ax</key><value>TXn_ampl</value></param>
<param><key>CtCr</key><value>CtCr</value></param>
<param><key>Dz</key><value>Dz</value></param>
</block>
<block>
<key>vlp2_trilat_scaleable_ff</key>
<param><key>id</key><value>vlp2_trilat_scaleable_ff_0</value></param>
<param><key>tx_number</key><value>4</value></param>
<param><key>tx_coords</key><value>(TX1_location, TX2_location, TX3_location, TX4_location)</value></param>
<param><key>tx_z</key><value>Dz</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_1</source_block_id><sink_block_id>blocks_float_to_complex_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>vlc_channel_relative_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>vlc_channel_relative_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_2</source_block_id><sink_block_id>vlc_channel_relative_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_3</source_block_id><sink_block_id>vlc_channel_relative_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>goertzel_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>goertzel_fc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>goertzel_fc_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>goertzel_fc_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1</source_block_id><sink_block_id>Position</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1_0</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_2</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>Position</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0_1</source_block_id><sink_block_id>blocks_complex_to_mag_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0_2</source_block_id><sink_block_id>blocks_complex_to_mag_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>blocks_null_sink_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
</flow_graph>
