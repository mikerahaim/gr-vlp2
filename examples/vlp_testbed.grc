<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>vlp_testbed</value></param>
<param><key>author</key><value>Richard McAllister, Mike Rahaim</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>VLP Testbed </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CtCr</value></param>
<param><key>value</key><value>(1,1,1,1,1,1,1,1,1,1,1,1,1,1,1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX_ampl</value></param>
<param><key>value</key><value>.7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX_coords</value></param>
<param><key>value</key><value>( (3.337,1.32,dZ ), (3.337, .81,dZ), (3.337, .3, dZ), (2.667, 1.32, dZ), (2.667, .81, dZ), (2.667, .3, dZ), (2.017, 1.32, dZ), (2.017, .81, dZ), (2.017, .3, dZ), (1.39,1.32,dZ), (1.39,.81,dZ), (1.39,.3,dZ), (.73,1.32,dZ), (.73,.81,dZ), (.73,.3,dZ) ) </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX_freqs</value></param>
<param><key>value</key><value>(1e5, 1.5e5, 2e5,2.5e5,3e5,3.5e5,4e5,4.5e5,5e5, 5.5e5, 6e5, 6.5e5,7e5,7.5e5,8e5)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dZ</value></param>
<param><key>value</key><value>1.355</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>goertzel_size</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lam_order</value></param>
<param><key>value</key><value>.88</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(2e6)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_number</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>500</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>.002</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>multi_goertzel</key>
<param><key>id</key><value>multi_goertzel_0</value></param>
<param><key>mult</key><value>2</value></param>
<param><key>freqs</key><value>TX_freqs</value></param>
<param><key>goertzel_size</key><value>goertzel_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>0</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>vlp2_amp2d_ff</key>
<param><key>id</key><value>vlp2_amp2d_ff_0</value></param>
<param><key>fov</key><value>90</value></param>
<param><key>n</key><value>1</value></param>
<param><key>Ts</key><value>1</value></param>
<param><key>m</key><value>1</value></param>
<param><key>tx_number</key><value>15</value></param>
<param><key>A</key><value>1</value></param>
<param><key>R</key><value>1</value></param>
<param><key>Ax</key><value>TX_ampl</value></param>
<param><key>CtCr</key><value>CtCr</value></param>
<param><key>Dz</key><value>dZ</value></param>
</block>
<block>
<key>vlp2_trilat_scaleable_ff</key>
<param><key>id</key><value>vlp2_trilat_scaleable_ff_0</value></param>
<param><key>tx_number</key><value>tx_number</value></param>
<param><key>tx_coords</key><value>TX_coords</value></param>
<param><key>tx_z</key><value>dZ</value></param>
</block>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multi_goertzel_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multi_goertzel_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>multi_goertzel_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>10</source_key><sink_key>10</sink_key></connection>
<connection><source_block_id>multi_goertzel_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>11</source_key><sink_key>11</sink_key></connection>
<connection><source_block_id>multi_goertzel_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>12</source_key><sink_key>12</sink_key></connection>
<connection><source_block_id>multi_goertzel_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>13</source_key><sink_key>13</sink_key></connection>
<connection><source_block_id>multi_goertzel_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>14</source_key><sink_key>14</sink_key></connection>
<connection><source_block_id>multi_goertzel_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>multi_goertzel_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>multi_goertzel_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>multi_goertzel_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>multi_goertzel_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>6</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>multi_goertzel_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>7</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>multi_goertzel_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>8</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>multi_goertzel_0</source_block_id><sink_block_id>vlp2_amp2d_ff_0</sink_block_id><source_key>9</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>multi_goertzel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>10</source_key><sink_key>10</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>11</source_key><sink_key>11</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>12</source_key><sink_key>12</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>13</source_key><sink_key>13</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>14</source_key><sink_key>14</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>6</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>7</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>8</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>vlp2_amp2d_ff_0</source_block_id><sink_block_id>vlp2_trilat_scaleable_ff_0</sink_block_id><source_key>9</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vlp2_trilat_scaleable_ff_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
</flow_graph>
